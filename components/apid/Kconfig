## components/apid/Kconfig
```kconfig
menu "IDS"
	
	config IDS_LOG
		bool "Enable Log for ids component"
		default y
		help 
			Enable IDS Log

endmenu
```
